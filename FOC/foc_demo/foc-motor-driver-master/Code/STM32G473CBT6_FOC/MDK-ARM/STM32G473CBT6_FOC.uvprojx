# Keil uVision project STM32G473CBT6_FOC.uvprojx, settings and files
target STM32G473CBT6_FOC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G473CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32G473CBT6_FOC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G473xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;./other_file/system_m4;./other_file/bsp;./other_file/usb/USB_APP;./other_file/usb/STM32_USB_Device_Library/Class/CDC/Inc;./other_file/usb/STM32_USB_Device_Library/Core/Inc;./other_file/foc;./other_file/dsp_m4/Include;./other_file/DEBUG
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c usb.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group dsp
    ./other_file/dsp_m4/: arm_cortexM4lf_math.lib
  group system
    ./other_file/system_m4/: delay.c my_usart.c sys.c
  group bsp
    ./other_file/bsp/: bsp.c bsp_irq.c
    ./other_file/bsp/cc6920so/: cc6920so.c
  group usb/core
    ./other_file/usb/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group usb/device
    ./other_file/usb/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group usb/user
    ./other_file/usb/USB_APP/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group debug
    ./other_file/DEBUG/: debug.c
  group foc
    ./other_file/foc/: foc_hw.c foc_app.c foc_motor.c foc_current.c foc_filter.c foc_hfi.c foc_math.c foc_pid.c foc_pwm.c foc_sensorless.c foc_smo.c foc_vf.c foc_hall.c foc_flux.c foc_identify.c foc_vbus.c foc_abzenc.c foc_read.txt
