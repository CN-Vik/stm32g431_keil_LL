# Keil uVision project stm32g431_keil_pro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32g431_keil_pro
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: RTOS:Config 11.1.0, RTOS:Core 11.1.0, RTOS:Coroutines 11.1.0, RTOS:Event Groups 11.1.0, RTOS:Heap 11.1.0, RTOS:Message Buffer 11.1.0, RTOS:Stream Buffer 11.1.0, RTOS:Timers 11.1.0, CMSIS Driver:CAN:Custom 1.0.0, CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:GPIO:Custom 1.0.0, CMSIS Driver:I2C:Custom 1.0.0, CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS Driver:USB Host:Custom 1.0.0, CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, CMSIS:NN Lib 7.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.1.0, CMSIS Driver:SPI 1.1.0, CMSIS Driver:SPI:Multi-Slave 1.0.1, CMSIS Driver:USART 1.0.0
